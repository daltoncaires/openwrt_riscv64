## image/Config.in
```kconfig
config RISCV64_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_riscv64
	default 32
```
